MACRO nor2 (1)
  CLASS BLOCK ;
  FOREIGN nor2 (1) ;
  ORIGIN 0.000 0.120 ;
  SIZE 10.000 BY 2.960 ;
  OBS
      LAYER nwell ;
        RECT 0.000 1.060 10.000 2.720 ;
      LAYER li1 ;
        RECT 0.340 2.770 0.510 2.810 ;
        RECT 1.670 2.770 1.840 2.800 ;
        RECT 2.990 2.770 3.160 2.800 ;
        RECT 4.120 2.770 4.290 2.800 ;
        RECT 5.700 2.770 5.870 2.810 ;
        RECT 0.000 2.600 10.000 2.770 ;
        RECT 0.340 2.360 0.520 2.600 ;
        RECT 1.660 2.370 1.840 2.600 ;
        RECT 0.290 2.000 0.590 2.360 ;
        RECT 1.600 2.010 1.900 2.370 ;
        RECT 2.980 2.350 3.160 2.600 ;
        RECT 4.120 2.400 4.290 2.600 ;
        RECT 2.930 1.990 3.230 2.350 ;
        RECT 4.060 2.040 4.360 2.400 ;
        RECT 5.700 2.390 5.880 2.600 ;
        RECT 5.640 2.020 5.950 2.390 ;
        RECT 6.170 1.960 9.010 2.140 ;
        RECT 6.170 1.720 6.340 1.960 ;
        RECT 7.500 1.730 7.670 1.960 ;
        RECT 8.840 1.730 9.010 1.960 ;
        RECT 0.930 1.580 1.270 1.690 ;
        RECT 2.250 1.580 2.590 1.700 ;
        RECT 3.550 1.590 3.890 1.700 ;
        RECT 6.090 1.590 6.430 1.720 ;
        RECT 3.550 1.580 6.430 1.590 ;
        RECT 0.930 1.410 6.430 1.580 ;
        RECT 0.930 1.290 1.270 1.410 ;
        RECT 2.250 1.300 2.590 1.410 ;
        RECT 3.550 1.300 3.890 1.410 ;
        RECT 6.090 1.320 6.430 1.410 ;
        RECT 6.760 1.320 7.100 1.720 ;
        RECT 7.410 1.330 7.750 1.730 ;
        RECT 8.080 1.330 8.420 1.730 ;
        RECT 8.750 1.330 9.090 1.730 ;
        RECT 9.400 1.330 9.740 1.730 ;
        RECT 6.850 1.020 7.020 1.320 ;
        RECT 8.160 1.020 8.330 1.330 ;
        RECT 9.480 1.020 9.650 1.330 ;
        RECT 1.030 0.850 10.000 1.020 ;
        RECT 1.030 0.660 1.200 0.850 ;
        RECT 2.340 0.660 2.510 0.850 ;
        RECT 0.250 0.260 0.590 0.660 ;
        RECT 0.940 0.260 1.280 0.660 ;
        RECT 1.580 0.260 1.920 0.660 ;
        RECT 2.250 0.260 2.590 0.660 ;
        RECT 2.800 0.260 3.170 0.670 ;
        RECT 3.830 0.270 4.200 0.680 ;
        RECT 8.170 0.660 8.340 0.850 ;
        RECT 9.480 0.660 9.650 0.850 ;
        RECT 0.340 0.080 0.510 0.260 ;
        RECT 1.670 0.080 1.840 0.260 ;
        RECT 2.900 0.080 3.070 0.260 ;
        RECT 5.810 0.250 6.190 0.660 ;
        RECT 6.880 0.270 7.220 0.660 ;
        RECT 6.960 0.080 7.130 0.270 ;
        RECT 7.400 0.260 7.740 0.660 ;
        RECT 8.080 0.260 8.420 0.660 ;
        RECT 8.750 0.260 9.090 0.660 ;
        RECT 9.390 0.260 9.730 0.660 ;
        RECT 7.480 0.080 7.650 0.260 ;
        RECT 8.850 0.080 9.020 0.260 ;
        RECT 0.000 -0.090 10.000 0.080 ;
      LAYER met1 ;
        RECT 0.000 2.600 10.000 2.840 ;
        RECT 0.000 -0.120 10.000 0.120 ;
  END
END nor2 (1)
END LIBRARY

